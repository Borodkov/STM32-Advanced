# IAR project ADC_MultiChan_TCP_CLI.ewp, settings and files
configuration ADC_MultiChan_TCP_CLI (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_apps; ..\..\_apps\CLI; ..\..\_apps\JPG; ..\..\_bsp; ..\..\_common; ..\..\_libs\FatFs\; ..\..\_libs\FatFs\ff13b\source; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS\Source\include; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS\Source\CMSIS_RTOS; ..\..\_libs\FreeModbus\ascii; ..\..\_libs\FreeModbus\functions; ..\..\_libs\FreeModbus\include; ..\..\_libs\FreeModbus\port; ..\..\_libs\FreeModbus\rtu; ..\..\_libs\FreeModbus\tcp; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy; ..\..\..\STM32Cube_FW_F7\Middlewares\Third_Party\LibJPEG\include; ..\..\..\STM32Cube_FW_F7\Middlewares\Third_Party\LWIP\src\include; ..\..\..\STM32Cube_FW_F7\Middlewares\Third_Party\LWIP\system; ..\..\..\STM32Cube_FW_F7\Utilities\CPU; ..\..\..\STM32Cube_FW_F7\Utilities\Log
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: ADC_MultiChan_TCP_CLI.hex
  ILINK.IlinkOutputFile: ADC_MultiChan_TCP_CLI.out
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_QSPI_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../_apps/: app_adc.c app_btn.c app_encoder.c app_eth_dhcp.c app_eth_httpserver.c app_eth_udpsyslog.c app_fractal.c app_mandelbrot.c app_modbus.c app_rtc.c app_slideshow.c app_uart.c app_viewString.c
    ../../_apps/JPG/: app_jpeg.c
    ../../_common/: ethernetif.c hr_gettime.c stm32f7xx_hal_timebase_TIM.c
    ../Src/: freertos.c main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
  group Application/CLI
    ../../_apps/CLI/: CLIcommands_Sample.c CLIconsole_TCP.c
  group Drivers
    ../../_bsp/: system_stm32f7xx.c
    ../../_IAR/: startup_stm32f746xx.s
  group Drivers/BSP
    ../../_bsp/: stm32746g_discovery.c stm32746g_discovery.h stm32746g_discovery_audio.c stm32746g_discovery_audio.h stm32746g_discovery_camera.c stm32746g_discovery_camera.h stm32746g_discovery_eeprom.c stm32746g_discovery_eeprom.h stm32746g_discovery_lcd.c stm32746g_discovery_lcd.h stm32746g_discovery_qspi.c stm32746g_discovery_qspi.h stm32746g_discovery_sd.c stm32746g_discovery_sd.h stm32746g_discovery_sdram.c stm32746g_discovery_sdram.h stm32746g_discovery_ts.c stm32746g_discovery_ts.h
  group Drivers/BSP/Components
    ../../_bsp/: ft5336.c ft5336.h ov9655.c ov9655.h wm8994.c wm8994.h
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group Middlewares/FatFs
    ../../_libs/FatFs/: diskio.c ff_gen_drv.c sd_diskio_dma.c
    ../../_libs/FatFs/ff13b/source/: ff.c ffsystem.c ffunicode.c
  group Middlewares/FreeModbus
    ../../_libs/FreeModbus/: mb.c
  group Middlewares/FreeModbus/ascii
    ../../_libs/FreeModbus/ascii/: mbascii.c mbascii.h
  group Middlewares/FreeModbus/functions
    ../../_libs/FreeModbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Middlewares/FreeModbus/include
    ../../_libs/FreeModbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group Middlewares/FreeModbus/port
    ../../_libs/FreeModbus/port/: port.h portevent.c portserial.c porttimer.c
  group Middlewares/FreeModbus/rtu
    ../../_libs/FreeModbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group Middlewares/FreeModbus/tcp
    ../../_libs/FreeModbus/tcp/: mbtcp.c mbtcp.h
  group Middlewares/FreeRTOS
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/cmsis
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.h
  group Middlewares/FreeRTOS/include
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Middlewares/FreeRTOS/portable
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group Middlewares/FreeRTOS-Plus
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c FreeRTOS_CLI.h
  group Middlewares/Lib_JPEG
    ../../../STM32Cube_FW_F7/Middlewares/Third_Party/LibJPEG/source/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group Middlewares/LwIP
    ../../../STM32Cube_FW_F7/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../STM32Cube_FW_F7/Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
    ../../../STM32Cube_FW_F7/Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../STM32Cube_FW_F7/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../STM32Cube_FW_F7/Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../STM32Cube_FW_F7/Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../STM32Cube_FW_F7/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../../../STM32Cube_FW_F7/Middlewares/Third_Party/LwIP/src/apps/httpd/: fs.c httpd.c
    ../../../STM32Cube_FW_F7/Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../STM32Cube_FW_F7/Middlewares/Third_Party/LwIP/src/apps/tftp/: tftp_server.c
  group Utilities
    ../../../STM32Cube_FW_F7/Utilities/CPU/: cpu_utils.c
    ../../../STM32Cube_FW_F7/Utilities/Log/: lcd_log.c
