# IAR project GrEq.ewp, settings and files
configuration GrEq-STM32F746G-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ARM_MATH_CM7; USE_HAL_DRIVER; STM32F746xx; USE_STM32746G_DISCO; USE_IOEXPANDER; USE_USB_FS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_bsp; ..\..\_common; ..\..\_common\Audio; ..\..\_libs\STM32_Audio\Addons\GREQ\Inc; ..\..\_libs\STM32_Audio\Addons\Common\Inc; ..\..\_libs\FatFs\; ..\..\_libs\FatFs\ff13b\source; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\STM32Cube_FW_F7\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\STM32Cube_FW_F7\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\STM32Cube_FW_F7\Utilities\Log; ..\..\..\STM32Cube_FW_F7\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Audio_GrEq.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../_common/Audio/: explorer.c menu.c stm32f7xx_it.c usbh_conf.c
    ../Src/: main.c waveplayer.c
  group Doc
    ../: readme.txt
  group Drivers
    ../../_IAR/: startup_stm32f746xx.s
    ../../_bsp/: system_stm32f7xx.c
  group Drivers/BSP/Components
    ../../_bsp/: ft5336.c wm8994.c
  group Drivers/BSP/STM32746G-Discovery
    ../../_bsp/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2s.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c
  group Middlewares/FatFs
    ../../_libs/FatFs/: diskio.c ff_gen_drv.c usbh_diskio.c
    ../../_libs/FatFs/ff13b/source/: ff.c ffunicode.c
  group Middlewares/GREQ
    ../../_libs/STM32_Audio/Addons/GREQ/Lib/: GrEq_CM7_IAR.a
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../STM32Cube_FW_F7/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../STM32Cube_FW_F7/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Utilities
    ../../../STM32Cube_FW_F7/Utilities/Log/: lcd_log.c
