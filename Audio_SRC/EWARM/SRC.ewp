# IAR project SRC.ewp, settings and files
configuration SRC-STM32F746G-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ARM_MATH_CM7; USE_HAL_DRIVER; STM32F746xx; USE_STM32746G_DISCO; USE_IOEXPANDER; USE_USB_FS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_common; ..\..\_common\Audio; ..\..\_libs\STM32_Audio\Addons\SRC236\Inc; ..\..\_libs\STM32_Audio\Addons\SRC441\Inc; ..\..\_libs\STM32_Audio\Addons\Common\Inc; ..\..\_libs\FatFs\; ..\..\_libs\FatFs\ff13b\source; ..\..\..\STM32Cube_FW_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\STM32746G-Discovery; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\Components\Common; ..\..\..\STM32Cube_FW_F7\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\STM32Cube_FW_F7\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\STM32Cube_FW_F7\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\STM32Cube_FW_F7\Utilities\Log; ..\..\..\STM32Cube_FW_F7\Utilities\Fonts; ..\..\..\STM32Cube_FW_F7\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Audio_SRC.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../_common/: startup_stm32f746xx.s
  group Application/User
    ../../_common/Audio/: explorer.c menu.c stm32f7xx_it.c usbh_conf.c usbh_diskio.c
    ../Src/: main.c waveplayer.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32746G-Discovery
    ../../../STM32Cube_FW_F7/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group Drivers/CMSIS
    ../../_common/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2s.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c
  group Middlewares/FatFs
    ../../_libs/FatFs/source/: ff.c
  group Middlewares/SRC
    ../../_libs/STM32_Audio/Addons/SRC236/Lib/: SRC236_CM7_IAR.a
    ../../_libs/STM32_Audio/Addons/SRC441/Lib/: SRC441_CM7_IAR.a
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../STM32Cube_FW_F7/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../STM32Cube_FW_F7/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Utilities
    ../../../STM32Cube_FW_F7/Utilities/Log/: lcd_log.c
