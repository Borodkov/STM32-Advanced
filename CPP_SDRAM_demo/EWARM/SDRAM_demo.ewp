# IAR project SDRAM_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_common; ..\..\_libs\mbed_CPP_drivers; ..\..\..\STM32Cube_FW_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\STM32746G-Discovery; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\Components\Common; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\Components\ft5336; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\Components\ov9655; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\Components\wm8994; ..\..\..\STM32Cube_FW_F7\Utilities\Log; ..\..\..\STM32Cube_FW_F7\Utilities\Fonts; ..\..\..\STM32Cube_FW_F7\Utilities\CPU
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_QSPI_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Src/: main.cpp stm32f7xx_it.c
    ../../_common/: startup_stm32f746xx.s
  group Drivers
    ../../_common/: system_stm32f7xx.c
  group Drivers/BSP
    ../../../STM32Cube_FW_F7/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_camera.c stm32746g_discovery_eeprom.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group Drivers/BSP/Components
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/ov9655/: ov9655.c
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/CPP
    ../../_libs/mbed_CPP_drivers/: AUDIO_DISCO_F746NG.cpp AUDIO_DISCO_F746NG.h EEPROM_DISCO_F746NG.cpp EEPROM_DISCO_F746NG.h LCD_DISCO_F746NG.cpp LCD_DISCO_F746NG.h QSPI_DISCO_F746NG.cpp QSPI_DISCO_F746NG.h SD_DISCO_F746NG.cpp SD_DISCO_F746NG.h SDRAM_DISCO_F746NG.cpp SDRAM_DISCO_F746NG.h TS_DISCO_F746NG.cpp TS_DISCO_F746NG.h
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_ll_fmc.c
  group Utilities
    ../../../STM32Cube_FW_F7/Utilities/Log/: lcd_log.c
