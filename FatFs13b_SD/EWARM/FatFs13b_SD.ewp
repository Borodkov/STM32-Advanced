# IAR project FatFs13b_SD.ewp, settings and files
configuration STM32F746G-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ARM_MATH_CM7; USE_HAL_DRIVER; STM32F746xx; USE_STM32746G_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_common; ..\..\_libs\FatFs\; ..\..\_libs\FatFs\ff13b\source; ..\..\..\STM32Cube_FW_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\STM32746G-Discovery; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\Components\Common; ..\..\..\STM32Cube_FW_F7\Utilities\Log; ..\..\..\STM32Cube_FW_F7\Utilities\Fonts; ..\..\..\STM32Cube_FW_F7\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: STM32F7Disco.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../_common/: startup_stm32f746xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32746G-Discovery
    ../../../STM32Cube_FW_F7/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_sd.c
  group Drivers/CMSIS
    ../../_common/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../../_libs/FatFs/: diskio.c ff_gen_drv.c sd_diskio.c
    ../../_libs/FatFs/ff13b/source/: ff.c ffsystem.c ffunicode.c
  group Utilities
    ../../../STM32Cube_FW_F7/Utilities/Log/: lcd_log.c
