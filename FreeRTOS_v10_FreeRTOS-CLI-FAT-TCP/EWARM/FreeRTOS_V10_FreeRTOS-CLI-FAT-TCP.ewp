# IAR project FreeRTOS_V10_FreeRTOS-CLI-FAT-TCP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCDiagSuppress: Pe1644
  ICCARM.CCIncludePath2: ..\Inc; ..\Src\FreeRTOS_Plus_CLI_Demos\include; ..\Src\FreeRTOS_Plus_TCP_Demos\include; ..\Src\FreeRTOS_Plus_TCP_Demos\TraceMacros\Example1; ..\Src\Utilities\include; ..\..\_apps; ..\..\_apps\CLI; ..\..\_apps\ETH; ..\..\_apps\FatFs; ..\..\_apps\JPG; ..\..\_apps\USB; ..\..\_apps\uSD; ..\..\_libs\FreeRTOS-Plus-FAT\include; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS\Source\include; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS\Source\CMSIS_RTOS; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS-Plus\Source\FreeRTOS-Plus-TCP\include; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS-Plus\Source\FreeRTOS-Plus-TCP\portable\Compiler\IAR; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS-Plus\Source\FreeRTOS-Plus-TCP\portable\NetworkInterface\include; ..\..\_libs\FreeRTOSv10.0.0\FreeRTOS-Plus\Source\FreeRTOS-Plus-TCP\protocols\include; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\STM32746G-Discovery; ..\..\..\STM32Cube_FW_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy; ..\..\..\STM32Cube_FW_F7\Utilities\CPU; ..\..\..\STM32Cube_FW_F7\Utilities\Log
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: FreeRTOS_V10_FreeRTOS-TCP.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_QSPI_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/CLI_Demos
    ../Src/FreeRTOS_Plus_CLI_Demos/: File-related-CLI-commands.c Sample-CLI-commands.c TCP-related-CLI-commands.c UDPCommandConsole.c UDPCommandConsole.h
  group Application/FAT_Demos
    ../Src/FreeRTOS_Plus_FAT_Demos/: CreateAndVerifyExampleFiles.c
    ../Src/FreeRTOS_Plus_FAT_Demos/test/: ff_stdio_tests_with_cwd.c
  group Application/TCP_Demos
    ../Src/FreeRTOS_Plus_TCP_Demos/: SimpleTCPEchoServer.c TCPEchoClient_SingleTasks.c TFTPServer.c
  group Application/TCP_Demos/include
    ../Src/FreeRTOS_Plus_TCP_Demos/include/: DefaultWebPages.h SimpleTCPEchoServer.h TCPEchoClient_SingleTasks.h TFTPServer.h
  group Application/TCP_Demos/TraceMacros
    ../Src/FreeRTOS_Plus_TCP_Demos/TraceMacros/Example1/: DemoIPTrace.c DemoIPTrace.h
  group Application/User
    ../Src/: main.c
    ../../_apps/: startup_stm32f746xx.s stm32f7xx_hal_timebase_TIM.c
  group Application/Utilities
    ../Src/Utilities/: date_and_time.c printf-stdarg.c UDPLoggingPrintf.c
  group Application/Utilities/include
    ../Src/Utilities/include/: date_and_time.h UDPLoggingPrintf.h
  group Drivers/BSP
    ../../../STM32Cube_FW_F7/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery.h stm32746g_discovery_audio.c stm32746g_discovery_audio.h stm32746g_discovery_camera.c stm32746g_discovery_camera.h stm32746g_discovery_eeprom.c stm32746g_discovery_eeprom.h stm32746g_discovery_lcd.c stm32746g_discovery_lcd.h stm32746g_discovery_qspi.c stm32746g_discovery_qspi.h stm32746g_discovery_sd.c stm32746g_discovery_sd.h stm32746g_discovery_sdram.c stm32746g_discovery_sdram.h stm32746g_discovery_ts.c stm32746g_discovery_ts.h
  group Drivers/BSP/Components
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/ft5336/: ft5336.c ft5336.h
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/ov9655/: ov9655.c ov9655.h
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/wm8994/: wm8994.c wm8994.h
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group Middlewares/FreeRTOS
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/include
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Middlewares/FreeRTOS/portable
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group Middlewares/FreeRTOS-Plus-CLI
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c FreeRTOS_CLI.h
  group Middlewares/FreeRTOS-Plus-FAT
    ../../_libs/FreeRTOS-Plus-FAT/: ff_crc.c ff_dev_support.c ff_dir.c ff_error.c ff_fat.c ff_file.c ff_format.c ff_ioman.c ff_locking.c ff_memory.c ff_stdio.c ff_string.c ff_sys.c ff_time.c
  group Middlewares/FreeRTOS-Plus-FAT/include
    ../../_libs/FreeRTOS-Plus-FAT/include/: ff_crc.h ff_devices.h ff_dir.h ff_error.h ff_fat.h ff_fatdef.h ff_file.h ff_format.h ff_headers.h ff_ioman.h ff_locking.h ff_old_config.h ff_stdio.h ff_string.h ff_sys.h ff_time.h FreeRTOS_erno_FAT.h FreeRTOSFATConfigDefaults.h
  group Middlewares/FreeRTOS-Plus-FAT/portable
    ../../_libs/FreeRTOS-Plus-FAT/portable/: ff_ramdisk.c ff_ramdisk.h ff_sddisk.c ff_sddisk.h
  group Middlewares/FreeRTOS-Plus-TCP
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
  group Middlewares/FreeRTOS-Plus-TCP/include
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/include/: FreeRTOS_ARP.h FreeRTOS_DHCP.h FreeRTOS_DNS.h FreeRTOS_errno_TCP.h FreeRTOS_IP.h FreeRTOS_IP_Private.h FreeRTOS_Sockets.h FreeRTOS_Stream_Buffer.h FreeRTOS_TCP_IP.h FreeRTOS_TCP_WIN.h FreeRTOS_UDP_IP.h FreeRTOSIPConfigDefaults.h IPTraceMacroDefaults.h NetworkBufferManagement.h NetworkInterface.h
  group Middlewares/FreeRTOS-Plus-TCP/portable
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/portable/BufferManagement/: BufferAllocation_2.c
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/portable/NetworkInterface/STM32F7xx/: NetworkInterface.c
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/portable/NetworkInterface/Common/: phyHandling.c
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/portable/NetworkInterface/include/: phyHandling.h
  group Middlewares/FreeRTOS-Plus-TCP/protocols
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/protocols/FTP/: FreeRTOS_FTP_commands.c FreeRTOS_FTP_server.c
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/protocols/HTTP/: FreeRTOS_HTTP_commands.c FreeRTOS_HTTP_server.c
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/protocols/Common/: FreeRTOS_TCP_server.c
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/protocols/NTP/: NTPDemo.c
  group Middlewares/FreeRTOS-Plus-TCP/protocols/include
    ../../_libs/FreeRTOSv10.0.0/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/protocols/include/: FreeRTOS_FTP_commands.h FreeRTOS_HTTP_commands.h FreeRTOS_server_private.h FreeRTOS_TCP_server.h NTPClient.h NTPDemo.h
