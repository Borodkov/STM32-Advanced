# IAR project Performance.ewp, settings and files
configuration 1-FlashITCM_rwRAM-DTCM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756NG ST STM32F756NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: PROJ_MENU_NB=1; STM32F756xx; CORE_CM7; USE_HAL_DRIVER; USE_IOEXPANDER; FLASH_WS=FLASH_LATENCY_7; ARM_MATH_CM7; __FPU_PRESENT=1; ART_ENABLE; PF_ART_ENABLE; PRINTF_LCD
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_common; ..\..\..\STM32Cube_FW_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\STM32746G-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: INITIAL_SP_BASE_ADDRESS=0x20010000
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: 1-FlashITCM_rwRAM-DTCM.out
  ILINK.IlinkIcfFile: 1-FlashITCM_rwRAM-DTCM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 2-FlashITCM_rwSRAM1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PROJ_MENU_NB=2; STM32F756xx; CORE_CM7; USE_HAL_DRIVER; USE_IOEXPANDER; FLASH_WS=FLASH_LATENCY_7; ARM_MATH_CM7; __FPU_PRESENT=1; ART_ENABLE; PF_ART_ENABLE; DCACHE_ENABLE; PRINTF_LCD
  AARM.ADefines: INITIAL_SP_BASE_ADDRESS=0x20000000
  ILINK.IlinkOutputFile: 2-FlashITCM_rwSRAM1.out
  ILINK.IlinkIcfFile: 2-FlashITCM_rwSRAM1.icf
configuration 3-FlashAXI_rwRAM-DTCM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PROJ_MENU_NB=3; STM32F756xx; USE_HAL_DRIVER; USE_IOEXPANDER; FLASH_WS=FLASH_LATENCY_7; ARM_MATH_CM7; __FPU_PRESENT; ICACHE_ENABLE; DCACHE_ENABLE; PRINTF_LCD
  ILINK.IlinkOutputFile: 3-FlashAXI_rwRAM-DTCM.out
  ILINK.IlinkIcfFile: 3-FlashAXI_rwRAM-DTCM.icf
configuration 4-FlashAXI_rwSRAM1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PROJ_MENU_NB=4; STM32F756xx; USE_HAL_DRIVER; USE_IOEXPANDER; FLASH_WS=FLASH_LATENCY_7; ARM_MATH_CM7; __FPU_PRESENT=1; ICACHE_ENABLE; DCACHE_ENABLE; PRINTF_LCD
  AARM.ADefines: INITIAL_SP_BASE_ADDRESS=0x20000000
  ILINK.IlinkOutputFile: 4-FlashAXI_rwSRAM1.out
  ILINK.IlinkIcfFile: 4-FlashAXI_rwSRAM1.icf
configuration 5-RamITCM_rwRAM-DTCM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PROJ_MENU_NB=5; STM32F756xx; USE_HAL_DRIVER; USE_IOEXPANDER; FLASH_WS=FLASH_LATENCY_7; ARM_MATH_CM7; __FPU_PRESENT=1; PRINTF_LCD
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: 5-RamITCM_rwRAM-DTCM.out
  ILINK.IlinkIcfFile: 5-RamITCM_rwRAM-DTCM.icf
configuration 6_1-QuadSPI_rwRAM-DTCM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PROJ_MENU_NB=6; PROJ_SUB_MENU_NB=1; STM32F756xx; USE_HAL_DRIVER; USE_IOEXPANDER; FLASH_WS=FLASH_LATENCY_7; DATA_IN_QSPI; QSPI_CLOCK_PRESCALER=3; QSPI_DDRMODE; QSPI_INSRUCTION_1_LINE; QSPI_XIP_MODE; __FPU_PRESENT=1; ARM_MATH_CM7; ICACHE_ENABLE; DCACHE_ENABLE; PRINTF_LCD
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: 6_1-QuadSPI_rwRAM-DTCM.out
  ILINK.IlinkIcfFile: 6_1-QuadSPI_rwRAM-DTCM.icf
configuration 6_2-QuadSPI_rwRAM-DTCM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PROJ_MENU_NB=6; PROJ_SUB_MENU_NB=2; STM32F756xx; USE_HAL_DRIVER; USE_IOEXPANDER; FLASH_WS=FLASH_LATENCY_7; DATA_IN_QSPI; QSPI_CLOCK_PRESCALER=3; QSPI_DDRMODE; QSPI_INSRUCTION_1_LINE; QSPI_XIP_MODE; __FPU_PRESENT=1; ARM_MATH_CM7; ICACHE_ENABLE; ART_ENABLE; PF_ART_ENABLE; PRINTF_LCD
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: 6_2-QuadSPI_rwRAM-DTCM.out
  ILINK.IlinkIcfFile: 6_2-QuadSPI_rwRAM-DTCM.icf
configuration 7-ExtSDRAM-Swapped_rwDTCM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PROJ_MENU_NB=7; STM32F756xx; CORE_CM7; USE_HAL_DRIVER; USE_IOEXPANDER; FLASH_WS=FLASH_LATENCY_6; ARM_MATH_CM7; __FPU_PRESENT=1; DATA_IN_ExtSDRAM; SDRAM_ADDRESS_SWAPPED; SDRAM_MEM_BUS_WIDTH=FMC_SDRAM_MEM_BUS_WIDTH_32; ICACHE_ENABLE; DCACHE_ENABLE; PRINTF_LCD
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: 7-ExtSDRAM-Swapped_rwDTCM.out
  ILINK.IlinkIcfFile: 7-ExtSDRAM-Swapped_rwDTCM.icf
  group Doc
    ../: readme.txt
  group Drivers
    ../../_common/: system_stm32f7xx.c startup_stm32f746xx.s
  group Drivers/BSP
    ../../../STM32Cube_FW_F7/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery.h stm32746g_discovery_lcd.c stm32746g_discovery_lcd.h stm32746g_discovery_sdram.c stm32746g_discovery_sdram.h stm32746g_discovery_ts.c stm32746g_discovery_ts.h
  group Drivers/BSP/Components
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/ft5336/: ft5336.c ft5336.h
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/ov9655/: ov9655.c ov9655.h
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/wm8994/: wm8994.c wm8994.h
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_fmc.c
  group Example
    ../Src/: main.c print_config.c serial.c signal_input.c stm32f7xx_hal_msp.c stm32f7xx_it.c sysinit.c
