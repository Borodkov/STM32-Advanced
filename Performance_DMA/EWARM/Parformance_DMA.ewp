# IAR project Parformance_DMA.ewp, settings and files
configuration 1-FlashITCM_rwRAM-DTCM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: PROJ_MENU_NB=1; STM32F746xx; CORE_CM7; USE_HAL_DRIVER; USE_IOEXPANDER; FLASH_WS=FLASH_LATENCY_6; DATA_IN_ExtSDRAM; SDRAM_ADDRESS_SWAPPED; SDRAM_MEM_BUS_WIDTH=FMC_SDRAM_MEM_BUS_WIDTH_32; ARM_MATH_CM7; __FPU_PRESENT=1; ART_ENABLE; PF_ART_ENABLE; DCACHE_ENABLE
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_bsp; ..\..\_common; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: INITIAL_SP_BASE_ADDRESS=0x2004BC00
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: 1-FlashITCM_rwRAM-DTCM.out
  ILINK.IlinkIcfFile: 1-FlashITCM_rwRAM-DTCM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 2-FlashITCM_rwSRAM1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PROJ_MENU_NB=2; STM32F746xx; CORE_CM7; USE_HAL_DRIVER; USE_IOEXPANDER; FLASH_WS=FLASH_LATENCY_6; DATA_IN_ExtSDRAM; SDRAM_ADDRESS_SWAPPED; SDRAM_MEM_BUS_WIDTH=FMC_SDRAM_MEM_BUS_WIDTH_32; ARM_MATH_CM7; __FPU_PRESENT=1; ART_ENABLE; PF_ART_ENABLE; DCACHE_ENABLE
  ILINK.IlinkOutputFile: 2-FlashITCM_rwSRAM1.out
  ILINK.IlinkIcfFile: 2-FlashITCM_rwSRAM1.icf
configuration 3-FlashAXI_rwRAM-DTCM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PROJ_MENU_NB=3; STM32F746xx; USE_HAL_DRIVER; USE_IOEXPANDER; FLASH_WS=FLASH_LATENCY_6; DATA_IN_ExtSDRAM; SDRAM_ADDRESS_SWAPPED; SDRAM_MEM_BUS_WIDTH=FMC_SDRAM_MEM_BUS_WIDTH_32; ARM_MATH_CM7; __FPU_PRESENT; ICACHE_ENABLE; DCACHE_ENABLE
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: 3-FlashAXI_rwRAM-DTCM.out
  ILINK.IlinkIcfFile: 3-FlashAXI_rwRAM-DTCM.icf
  group Doc
    ../: readme.txt
  group Drivers
    ../../_bsp/: system_stm32f7xx.c
    ../../_IAR/: startup_stm32f746xx.s
  group Drivers/BSP/BSP
    ../../_bsp/: stm32746g_discovery.c stm32746g_discovery.h stm32746g_discovery_lcd.c stm32746g_discovery_lcd.h stm32746g_discovery_sdram.c stm32746g_discovery_sdram.h stm32746g_discovery_ts.c stm32746g_discovery_ts.h
  group Drivers/BSP/BSP/Components
    ../../_bsp/: ft5336.c ft5336.h ov9655.c ov9655.h wm8994.c wm8994.h
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spi.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_fmc.c
  group Example
    ../Src/: end.c main.c print_config.c serial.c signal_input.c stm32f7xx_hal_msp.c stm32f7xx_it.c system_init.c
