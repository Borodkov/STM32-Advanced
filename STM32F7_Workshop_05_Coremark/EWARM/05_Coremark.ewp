# IAR project 05_Coremark.ewp, settings and files
configuration STM32F746-Disco(AXI) (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USE_STM32746G_DISCO; USE_IOEXPANDER; __DBG_ITM; ARM_MATH_CM7
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_bsp; ..\..\_bsp\cpp_wrappers; ..\..\_common; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Utilities\Log; ..\..\..\STM32Cube_FW_F7\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32756G_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: __iar_sh_stdout_swo
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_AXI_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F746-Disco(TCMRAM) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_bsp; ..\..\_common; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Utilities\Log; ..\..\..\STM32Cube_FW_F7\Utilities\CPU
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_ITCM_ram.icf
configuration STM32F746-Disco(TCM) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_ITCM_flash.icf
configuration STM32F746-Disco(QSPI) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_QSPI_flash.icf
configuration STM32F746-Disco(SDRAM) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USE_STM32746G_DISCO; __DBG_ITM; ARM_MATH_CM7
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: 05_Coremark.hex
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_sdram.icf
  group Application
    ../Src/: core_portme.c Coremark_forIAR.a main.c stm32f7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers
    ../../_IAR/: startup_stm32f746xx.s
    ../../_bsp/: system_stm32f7xx.c
  group Drivers/BSP
    ../../_bsp/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sdram.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash.c stm32f7xx_hal_gpio.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_ll_fmc.c
  group Utilities
    ../../../STM32Cube_FW_F7/Utilities/Log/: lcd_log.c
