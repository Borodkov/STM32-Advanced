# IAR project 06_DSPaudio.ewp, settings and files
configuration STM32F746-Disco(AXI) (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756VG ST STM32F756VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F756xx; USE_STM32746G_DISCO; USE_IOEXPANDER; __DBG_ITM; ARM_MATH_CM7
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_common; ..\..\..\STM32Cube_FW_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\STM32746G-Discovery; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\Components\Common; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\Components\wm8994; ..\..\..\STM32Cube_FW_F7\Utilities\Log; ..\..\..\STM32Cube_FW_F7\Utilities\Fonts; ..\..\..\STM32Cube_FW_F7\Utilities\CPU; ..\..\..\STM32Cube_FW_F7\Middlewares\ST\STemWin\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 06_DSPaudio.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: __iar_sh_stdout_swo
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F746-Disco(TCM) (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: STM32756G_EVAL.hex
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_ITCM_flash.icf
  group Application/User
    ../Src/: color waves.c main.c scope.c stm32f7xx_it.c
    ../../_common/: startup_stm32f746xx.s
  group Drivers
    ../../_common/: system_stm32f7xx.c
  group Drivers/BSP
    ../../../STM32Cube_FW_F7/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c
  group Drivers/BSP/Components
    ../../../STM32Cube_FW_F7/Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/CMSIS
    ../../../STM32Cube_FW_F7/Drivers/CMSIS/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_q15.c arm_correlate_fast_q15.c arm_fir_fast_q15.c arm_fir_init_q15.c
    ../../../STM32Cube_FW_F7/Drivers/CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_mag_q15.c arm_cmplx_mag_squared_q15.c
    ../../../STM32Cube_FW_F7/Drivers/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_rfft_init_q15.c arm_rfft_q15.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_ll_fmc.c
  group Middleware/STemWin
    ../../../STM32Cube_FW_F7/Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Src/: GUIConf.c LCDConf.c
    ../../../STM32Cube_FW_F7/Middlewares/ST/STemWin/Lib/: STemWin540_CM7_IAR_ot.a
  group Utilities
    ../../../STM32Cube_FW_F7/Utilities/Log/: lcd_log.c
