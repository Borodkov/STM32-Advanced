# IAR project 07_Scope.ewp, settings and files
configuration STM32F746-Disco (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756NG ST STM32F756NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F756xx
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_common; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\Components; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\STM32746G-Discovery; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy; ..\..\..\STM32Cube_FW_F7\Drivers\CMSIS\Include; ..\..\..\STM32Cube_FW_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\STM32Cube_FW_F7\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\STM32Cube_FW_F7\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\STM32Cube_FW_F7\Middlewares\ST\STemWin\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 07_Scope.hex
  ILINK.IlinkOutputFile: STM32F746-Disco.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Src/: main.c scope.c stm32f7xx_hal_msp.c stm32f7xx_it.c usbd_cdc_if.c
    ../../_common/: usb_device.c usbd_conf.c usbd_desc_cdc.c
  group Drivers
    ../../_common/: system_stm32f7xx.c startup_stm32f746xx.s
  group Drivers/BSP
    ../../../STM32Cube_FW_F7/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash.c stm32f7xx_hal_gpio.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c
  group Middlewares/STemWin
    ../../../STM32Cube_FW_F7/Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Src/: GUIConf.c LCDConf.c
    ../../../STM32Cube_FW_F7/Middlewares/ST/STemWin/Lib/: STemWin540_CM7_IAR_ot.a
  group Middlewares/USB_Device_Library
    ../../../STM32Cube_FW_F7/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../STM32Cube_FW_F7/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
