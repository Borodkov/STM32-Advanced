# IAR project 08_QSPI_DMA2D_LTDC.ewp, settings and files
configuration STM32F746-Disco(QSPI) (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756VG ST STM32F756VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F756xx; USE_STM32746G_DISCO; USE_IOEXPANDER; __DBG_ITM; ARM_MATH_CM7
  ICCARM.CCIncludePath2: ..\Inc; ..\..\_apps; ..\..\_common; ..\..\..\STM32Cube_FW_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\STM32Cube_FW_F7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\STM32746G-Discovery; ..\..\..\STM32Cube_FW_F7\Drivers\BSP\Components\Common; ..\..\..\STM32Cube_FW_F7\Utilities\Log; ..\..\..\STM32Cube_FW_F7\Utilities\Fonts; ..\..\..\STM32Cube_FW_F7\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 08_QSPI_DMA2D_LTDC.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: __iar_sh_stdout_swo
  ILINK.IlinkIcfFile: ..\..\_IAR\stm32f746xx_QSPI_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Src/: main.c stm32f7xx_it.c
    ../../_common/: startup_stm32f746xx.s
  group Drivers
    ../../_common/: system_stm32f7xx.c
  group Drivers/BSP
    ../../../STM32Cube_FW_F7/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sdram.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../STM32Cube_FW_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash.c stm32f7xx_hal_gpio.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_ll_fmc.c
  group Utilities
    ../../../STM32Cube_FW_F7/Utilities/Log/: lcd_log.c
