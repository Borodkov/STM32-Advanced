<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\FatFs13b_SD\EWARM\FatFs13b_SD.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\FatFs13b_SD_DMA\EWARM\FatFs13b_SD_DMA.ewp</path>
    </project>
    <batchBuild />
</workspace>
