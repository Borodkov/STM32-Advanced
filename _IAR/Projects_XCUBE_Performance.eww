<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Performance_DSP_Demo\EWARM\DSP_Demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Performance_DMA\EWARM\Parformance_DMA.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Performance\EWARM\Performance.ewp</path>
    </project>
    <batchBuild />
</workspace>
