<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\lwip_TFTP\EWARM\lwip_TFTP.ewp</path>
    </project>
    <batchBuild />
</workspace>
